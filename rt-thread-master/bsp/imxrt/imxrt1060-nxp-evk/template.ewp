# IAR project template.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link_iar_nor_tcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration nor_txt_sdram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\link_iar_nor_sdram.icf
