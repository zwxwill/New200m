# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1062DVL6A; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\components\dfs\filesystems\devfs; ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\Libraries\MIMXRT1060\CMSIS\Include; ..\Libraries\MIMXRT1060\MIMXRT1062\middleware\sdmmc\inc; board\xip; ..\..\..\components\utilities\utest; ..\..\..\components\libc\compilers\dlib; ..\..\..\components\libc\compilers\common; ..\..\..\components\dfs\include; ..\Libraries\drivers\config; .; board; test; board\MCUX_Config; board\ports; ..\Libraries\drivers; applications; ..\..\..\components\dfs\filesystems\elmfat; ..\..\..\include; ..\..\..\components\utilities\ulog; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\Libraries\MIMXRT1060; ..\Libraries\MIMXRT1060\MIMXRT1062\drivers; ..\Libraries\MIMXRT1060\MIMXRT1062; ..\Libraries\MIMXRT1060\MIMXRT1062\middleware\sdmmc\port; ..\Libraries\MIMXRT1060\MIMXRT1062\components\phyksz8081
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link_iar_nor_tcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration nor_txt_sdram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\link_iar_nor_sdram.icf
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: app_led.c app_sd.c main.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_gpio.c drv_uart.c drv_rtc.c drv_sdram.c drv_rng.c drv_sd.c drv_usdhc.c
  group xip
    board/xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_sdram_ini_dcd.c
    ../Libraries/MIMXRT1060/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c
  group Doc
    board/doc/: Readme.c ReleaseNote.c
  group test
    test/: test_fatfs.c test_log.c test_performance.c test_sd.c test_sem.c test_utest.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_iar.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
  group utest
    ../../../components/utilities/utest/: utest.c
  group Libraries
    ../Libraries/MIMXRT1060/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../Libraries/MIMXRT1060/MIMXRT1062/: system_MIMXRT1062.c
    ../Libraries/MIMXRT1060/MIMXRT1062/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_semc.c fsl_usdhc.c fsl_dmamux.c fsl_edma.c fsl_lpuart_edma.c fsl_trng.c
    ../Libraries/MIMXRT1060/MIMXRT1062/middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../Libraries/MIMXRT1060/MIMXRT1062/middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_host.c fsl_sdmmc_event.c
