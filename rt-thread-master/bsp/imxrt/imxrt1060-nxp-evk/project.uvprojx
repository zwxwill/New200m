# Keil uVision project project.uvprojx, settings and files
target rtthread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.11.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .;..\..\..\include;applications;board;board\MCUX_Config;board\xip;board\ports;..\Libraries\drivers;..\Libraries\drivers\config;board;..\Libraries\MIMXRT1060;board;packages\cJSON-latest;packages\mbedtls-v2.6.0\mbedtls\include;packages\mbedtls-v2.6.0\mbedtls\include\mbedtls;packages\mbedtls-v2.6.0\ports\inc;packages\netutils-latest\tftp;.;packages\pahomqtt-latest\MQTTPacket\src;packages\pahomqtt-latest\MQTTClient-RT;packages\SystemView-latest;packages\SystemView-latest\SystemView_Src\Config;packages\SystemView-latest;packages\SystemView-latest\SystemView_Src\SEGGER;packages\webnet-latest\inc;test;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\net\lwip-2.1.0\src;..\..\..\components\net\lwip-2.1.0\src\include;..\..\..\components\net\lwip-2.1.0\src\arch\include;..\..\..\components\net\lwip-2.1.0\src\include\netif;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\utilities\ulog;..\..\..\components\utilities\utest;..\Libraries\MIMXRT1060\CMSIS\Include;..\Libraries\MIMXRT1060\MIMXRT1062;..\Libraries\MIMXRT1060\MIMXRT1062\drivers;..\Libraries\MIMXRT1060\MIMXRT1062\middleware\sdmmc\inc;..\Libraries\MIMXRT1060\MIMXRT1062\middleware\sdmmc\port;..\Libraries\MIMXRT1060\MIMXRT1062\components\phyksz8081
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link_nor_txt_sdram.sct
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: app_led.c app_sd.c main.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_gpio.c drv_uart.c drv_rtc.c drv_sdram.c drv_rng.c drv_sd.c drv_usdhc.c drv_eth.c
  group xip
    board/xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_sdram_ini_dcd.c
    ../Libraries/MIMXRT1060/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c
  group Doc
    board/doc/: Readme.c ReleaseNote.c
  group cJSON
    packages/cJSON-latest/: cJSON.c cJSON_port.c cJSON_util.c
  group mbedtls
    packages/mbedtls-v2.6.0/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.6.0/ports/src/: timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group NetUtils
    packages/netutils-latest/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt-latest/tests/: mqtt_test.c
  group trace
    packages/SystemView-latest/SystemView_Src/Config/: SEGGER_RTT_Device.c SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
    packages/SystemView-latest/SystemView_Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group WebNet
    packages/webnet-latest/src/: webnet.c wn_mimetype.c wn_request.c wn_session.c wn_utils.c wn_module.c
    packages/webnet-latest/module/: wn_module_asp.c wn_module_auth.c wn_module_cgi.c wn_module_index.c wn_module_alias.c wn_module_upload.c wn_module_ssi.c
    packages/webnet-latest/samples/: wn_sample.c wn_sample_upload.c
  group test
    test/: test_fatfs.c test_log.c test_performance.c test_sd.c test_sem.c test_tcp_client.c test_tcp_server.c test_udp_client.c test_upd_server.c test_utest.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../components/libc/compilers/common/: gmtime_r.c
  group lwIP
    ../../../components/net/lwip-2.1.0/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.1.0/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../../components/net/lwip-2.1.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.1.0/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.1.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../../components/net/lwip-2.1.0/src/apps/ping/: lwip_ping.c
  group netdev
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c proto_mbedtls.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
  group utest
    ../../../components/utilities/utest/: utest.c
  group Libraries
    ../Libraries/MIMXRT1060/MIMXRT1062/arm/: startup_MIMXRT1062.s
    ../Libraries/MIMXRT1060/MIMXRT1062/: system_MIMXRT1062.c
    ../Libraries/MIMXRT1060/MIMXRT1062/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_semc.c fsl_usdhc.c fsl_enet.c fsl_dmamux.c fsl_edma.c fsl_lpuart_edma.c fsl_trng.c
    ../Libraries/MIMXRT1060/MIMXRT1062/components/phyksz8081/: fsl_phy.c
    ../Libraries/MIMXRT1060/MIMXRT1062/middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../Libraries/MIMXRT1060/MIMXRT1062/middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_host.c fsl_sdmmc_event.c
software components: CMSIS:CORE 5.0.2
